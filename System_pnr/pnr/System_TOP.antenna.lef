

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO System_TOP 
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 7.047 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.8961 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 23.629 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 113.848 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 578.424 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2793.19 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.06379 LAYER VIA56 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 1.931 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.28811 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.842 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.24242 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 31.815 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 153.223 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 842.439 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 4063.1 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.06379 LAYER VIA56 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 1.317 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.33477 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.705 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2035 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 7.215 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.8966 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 189.794 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 920.271 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA45 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 4.819 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.1794 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 93.4334 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 445.949 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI[0]
  PIN SO[3] 
    ANTENNAPARTIALMETALAREA 0.217 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.04377 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.239 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.34199 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 27.387 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 131.924 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0413 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 66.0271 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 318.994 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.05285 LAYER VIA56 ;
  END SO[3]
  PIN SO[2] 
    ANTENNAPARTIALMETALAREA 2.109 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1443 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 10.404 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 50.2356 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.537 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 27.893 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 134.358 LAYER METAL5 ;
  END SO[2]
  PIN SO[1] 
    ANTENNADIFFAREA 0.537 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 7.723 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.5324 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1872 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 70.0756 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 339.9 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 3.62207 LAYER VIA34 ;
  END SO[1]
  PIN SO[0] 
    ANTENNAPARTIALMETALAREA 1.653 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.95093 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 36.899 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 177.677 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNADIFFAREA 0.6 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 9.853 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 47.5853 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 224.106 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 1089.91 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 4.11396 LAYER VIA67 ;
  END SO[0]
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.455 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.18855 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.534 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.57094 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.944 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.54304 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.869009 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 4.32568 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END REF_CLK
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.241 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.15921 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.145 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.88985 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 7.028 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.9971 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 2.87698 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 13.984 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN RST_N 
    ANTENNAPARTIALMETALAREA 1.257 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.04617 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 10.035 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 48.4608 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3198 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 235.016 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1138.99 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.85397 LAYER VIA56 ;
  END RST_N
  PIN UART_RX_IN 
    ANTENNAPARTIALMETALAREA 0.216 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.03896 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.227 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.09427 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.222 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.26022 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 18.636 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 89.8316 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4706 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 63.797 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 312.51 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.68696 LAYER VIA56 ;
  END UART_RX_IN
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 13.334 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 64.1365 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.105 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 13.977 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 65.9203 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.285117 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.655 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.34295 LAYER METAL3 ;
    ANTENNAGATEAREA 1.105 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 14.5698 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 68.9456 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.350457 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAGATEAREA 1.105 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 14.796 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 70.2079 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 0.415796 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 7.894 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 38.1625 LAYER METAL5 ;
    ANTENNAGATEAREA 1.105 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 21.9399 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 104.744 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAMAXCUTCAR 0.481135 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 8.468 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 40.9235 LAYER METAL6 ;
    ANTENNAGATEAREA 1.7199 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 122.382 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 593.992 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 2.68734 LAYER VIA67 ;
  END test_mode
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.255 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.22655 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.206 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.99326 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.798 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.0808 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 3.01084 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 14.6279 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 1.681 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.08561 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.243 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.17123 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 11.165 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 53.8961 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 3.666 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8259 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1066 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 131.37 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 641.056 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 4.40244 LAYER VIA67 ;
  END scan_rst
  PIN SE 
    ANTENNAPARTIALMETALAREA 4.77 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.9437 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 70.1097 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 334.922 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.327 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.76527 LAYER METAL3 ;
    ANTENNAGATEAREA 0.2457 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 71.4406 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 342.107 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA34 ;
  END SE
  PIN UART_TX_O 
  END UART_TX_O
  PIN parity_error 
    ANTENNAPARTIALMETALAREA 3.253 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6469 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.524 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 28.713 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 138.302 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 173.135 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 835.616 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.05453 LAYER VIA56 ;
  END parity_error
  PIN framing_error 
    ANTENNAPARTIALMETALAREA 1.053 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.06493 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.657 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.4026 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.604 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 28.549 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 137.513 LAYER METAL5 ;
  END framing_error
END System_TOP

END LIBRARY
